# Keil uVision project SIFU.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SIFU +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\HARDWARE\USART;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\TIMER;..\HARDWARE\QUEUE;..\HARDWARE\IO;..\HARDWARE\PWM;..\HARDWARE\ENCODER;..\HARDWARE;..\HARDWARE\RUN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/QUEUE/: queue.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ENCODER/: Encoder.c
    ../HARDWARE/RUN/: run.c
software components: CMSIS:CORE 4.3.0
